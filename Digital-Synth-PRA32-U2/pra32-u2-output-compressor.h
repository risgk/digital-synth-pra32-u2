#pragma once

#include "pra32-u2-common.h"
#include "pra32-u2-output-compressor-table.h"

// Feed-forward peak compressor for the final output, which also works as the
// limiter, followed by soft_clip_output() (1.0 = 1 << 23); always on.
// It has the same structure as PRA32_U2_OutputLimiter (look-ahead 1 ms, the
// peak held over the delay buffer, attack 1 ms, release 100 ms), but the gain
// is looked up in g_output_compressor_gain_table (generated by
// pra32-u2-generate-output-compressor-table.rb), which holds the soft-knee
// compression (2:1 above -6 dB), the ceiling (infinity:1 above the input 1.0),
// and the output gain (x 0.75, -2.5 dB).
// The processing time is the same for every sample (and every control
// interval): no division, and no branch that skips or adds work
class PRA32_U2_OutputCompressor {
  static_assert(SAMPLING_RATE == 48000, "the look-ahead time and the rates are for 48 kHz");

  static const uint32_t DELAY_BUFF_SIZE       = 64;
  static const uint32_t LOOK_AHEAD            = 48;  // 1 ms

  // The gain is recalculated once per control interval, and interpolated over
  // the samples in between, as PRA32_U2_Amp does
  static const uint8_t  CONTROL_INTERVAL_BITS = 2;

  // The peak is held over the samples in the delay buffer and the current one:
  // one block per control interval, and one more for the block in progress
  static const uint32_t PEAK_BLOCKS           = (LOOK_AHEAD >> CONTROL_INTERVAL_BITS) + 1;

  // 1 - e^(-1 / n) in Q24, where n is the time constant in control intervals
  // (12 kHz): attack 1 ms, release 100 ms
  static const int32_t  ATTACK_RATE           = 1341432;
  static const int32_t  RELEASE_RATE          = 13975;

  // The range of the envelope covered by the table; below it, the gain is the
  // first entry, and above it, the last one
  static const int32_t  ENVELOPE_MIN          = 1 << OUTPUT_COMPRESSOR_TABLE_MIN_BITS;
  static const int32_t  ENVELOPE_MAX          = (1 << (OUTPUT_COMPRESSOR_TABLE_MIN_BITS + OUTPUT_COMPRESSOR_TABLE_OCTAVES)) - 1;

  // The leading 1 of ENVELOPE_MIN is at bit (31 - TOP_CLZ)
  static const int32_t  TOP_CLZ               = 31 - OUTPUT_COMPRESSOR_TABLE_MIN_BITS;
  static const uint8_t  FRACTION_BITS         = 8;

  int32_t  m_delay_buff[2][DELAY_BUFF_SIZE];
  int32_t  m_dry_delay_buff[2][DELAY_BUFF_SIZE];
  uint32_t m_delay_wp;
  uint32_t m_count;
  int32_t  m_block_peak;
  int32_t  m_peaks[PEAK_BLOCKS];
  uint32_t m_peak_index;
  int32_t  m_envelope;
  int32_t  m_gain_current;
  int32_t  m_gain_next;
  int32_t  m_gain_step;

public:
  PRA32_U2_OutputCompressor()
  : m_delay_buff()
  , m_dry_delay_buff()
  , m_delay_wp()
  , m_count()
  , m_block_peak()
  , m_peaks()
  , m_peak_index()
  , m_envelope()
  , m_gain_current(g_output_compressor_gain_table[0])
  , m_gain_next(g_output_compressor_gain_table[0])
  , m_gain_step()
  {
  }

  // dry_input_int24 (FX Routing: Dry) is not compressed (or limited), but is delayed,
  // lowered by the output gain, and clipped with the output
  INLINE PRA32_U2_StereoSample process(PRA32_U2_StereoSample input_int24, PRA32_U2_StereoSample dry_input_int24) {
    const int32_t left_input_int24  = input_int24.left;
    const int32_t right_input_int24 = input_int24.right;

    int32_t left_abs  = (left_input_int24  < 0) ? -left_input_int24  : left_input_int24;
    int32_t right_abs = (right_input_int24 < 0) ? -right_input_int24 : right_input_int24;
    m_block_peak = maximum(m_block_peak, maximum(left_abs, right_abs));

    m_delay_buff[0][m_delay_wp] = left_input_int24;
    m_delay_buff[1][m_delay_wp] = right_input_int24;
    m_dry_delay_buff[0][m_delay_wp] = dry_input_int24.left;
    m_dry_delay_buff[1][m_delay_wp] = dry_input_int24.right;
    const uint32_t delay_rp = (m_delay_wp - LOOK_AHEAD) & (DELAY_BUFF_SIZE - 1);
    m_delay_wp = (m_delay_wp + 1) & (DELAY_BUFF_SIZE - 1);

    if ((m_count & ((1 << CONTROL_INTERVAL_BITS) - 1)) == 0) {
      update_gain();
    }
    ++m_count;

    m_gain_current = approach(m_gain_current, m_gain_next, m_gain_step);

    return { soft_clip_output(multiply_shift_right(m_delay_buff[0][delay_rp], m_gain_current, 16) +
                              multiply_shift_right(m_dry_delay_buff[0][delay_rp], OUTPUT_COMPRESSOR_OUTPUT_GAIN, 16)),
             soft_clip_output(multiply_shift_right(m_delay_buff[1][delay_rp], m_gain_current, 16) +
                              multiply_shift_right(m_dry_delay_buff[1][delay_rp], OUTPUT_COMPRESSOR_OUTPUT_GAIN, 16)) };
  }

private:
  INLINE void update_gain() {
    m_peaks[m_peak_index] = m_block_peak;
    m_block_peak = 0;
    m_peak_index = (m_peak_index + 1 == PEAK_BLOCKS) ? 0 : (m_peak_index + 1);

    int32_t peak_hold = 0;
    for (uint32_t i = 0; i < PEAK_BLOCKS; ++i) {
      peak_hold = maximum(peak_hold, m_peaks[i]);
    }

    const int32_t rate = (peak_hold > m_envelope) ? ATTACK_RATE : RELEASE_RATE;
    m_envelope += multiply_shift_right(peak_hold - m_envelope, rate, 24);

    // Pseudo-logarithmic index: the octave (from the count of the leading zeros,
    // CLZ: 1 instruction) and the SEGMENT_BITS bits below the leading 1; the next
    // FRACTION_BITS bits interpolate between the entries
    const uint32_t envelope   = clamp(m_envelope, ENVELOPE_MIN, ENVELOPE_MAX);
    const int32_t  clz        = __builtin_clz(envelope);
    const uint32_t normalized = envelope << (clz + 1);  // Without the leading 1
    const uint32_t index      = ((TOP_CLZ - clz) << OUTPUT_COMPRESSOR_TABLE_SEGMENT_BITS) +
                                (normalized >> (32 - OUTPUT_COMPRESSOR_TABLE_SEGMENT_BITS));
    const int32_t  fraction   = (normalized >> (32 - OUTPUT_COMPRESSOR_TABLE_SEGMENT_BITS - FRACTION_BITS)) &
                                ((1 << FRACTION_BITS) - 1);
    const int32_t  gain_0     = g_output_compressor_gain_table[index];
    const int32_t  gain_1     = g_output_compressor_gain_table[index + 1];
    m_gain_next = gain_0 + (((gain_1 - gain_0) * fraction) >> FRACTION_BITS);

    // Rounded up, so that the target is reached by the end of the interval
    const int32_t delta = m_gain_next - m_gain_current;
    m_gain_step = (maximum(delta, -delta) +
                   ((1 << CONTROL_INTERVAL_BITS) - 1)) >> CONTROL_INTERVAL_BITS;
  }
};
